# Keil uVision project empty_keil.uvprojx, settings and files
target empty_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  output: empty_keil +hex
  BeforeMake: cmd.exe /C "C:/TI/sysconfig_1.26.2/sysconfig_cli.bat -s C:/TI/mspm0_sdk_2_11_00_07/.metadata/product.json --script D:/ccs/workspace/code/empty/empty.syscfg -o D:/ccs/workspace/code/empty --compiler keil"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ../,C:/TI/mspm0_sdk_2_11_00_07/source/third_party/CMSIS/Core/Include,C:/TI/mspm0_sdk_2_11_00_07/source
  scatter file: ./mspm0g3507.sct
  link misc: C:/TI/mspm0_sdk_2_11_00_07/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Source
    ../: empty.c display.c display.h gray_sensor.c gray_sensor.h line_follow.c line_follow.h motor_drv8701.c motor_drv8701.h motor_tb6612.c motor_tb6612.h mpu6050.c mpu6050.h empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    C:/TI/mspm0_sdk_2_11_00_07/examples/nortos/LP_MSPM0G3507/driverlib/empty/keil/: startup_mspm0g350x_uvision.s
